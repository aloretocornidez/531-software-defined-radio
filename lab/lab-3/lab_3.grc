options:
  parameters:
    author: alan-manuel
    generate_options: qt_gui
    id: lab_3
    output_language: python
    title: lab_3
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    rangeType: int
    start: '10000000'
    step: '10000000'
    stop: '5000000000'
    value: '433000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/alan-manuel/Downloads/output
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/alan-manuel/Downloads/output
    repeat: 'True'
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
