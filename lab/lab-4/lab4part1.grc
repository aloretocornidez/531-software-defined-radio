options:
  parameters:
    author: alan-manuel
    generate_options: qt_gui
    id: lab4_fm_rec
    output_language: python
    title: Lab 4 FM Reciever
  states: {}

blocks:
- name: fm_station
  id: variable_qtgui_range
  parameters:
    label: FM Station
    rangeType: int
    start: '88100000'
    step: 200 * 10 ** 3
    stop: '107500000'
    value: '89100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: 100 * 10 ** -3
    stop: '1'
    value: 700 * 10 ** -3
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '6'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '48000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fm_station
    fftsize: '1024'
    name: '"Input Signal"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulated Audio"'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:192.168.2.1
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
